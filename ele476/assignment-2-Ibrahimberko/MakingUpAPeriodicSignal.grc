options:
  parameters:
    author: İbrahim Berk
    generate_options: qt_gui
    id: MakingUpAPeriodicSignal
    output_language: python
    title: Making Up A Periodic Signal
  states: {}

blocks:
- name: F0
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,4
    label: Fundamental Harmonic
    start: '0'
    step: '100'
    stop: '2000'
    value: '1000'
  states: {}
- name: h1
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 0,0,1,1
    label: 1st Harmonic
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: h2
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 0,5,1,1
    label: 2st Harmonic
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: h3
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 0,1,1,1
    label: 3rd Harmonic
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: h4
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 0,6,1,1
    label: 4rd Harmonic
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: h5
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 0,2,1,1
    label: 5th Harmonic
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: h6
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 0,7,1,1
    label: 6th Harmonic
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: h7
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 0,3,1,1
    label: 7th Harmonic
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: h8
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 0,8,1,1
    label: 8th harmonic
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: waveform
  id: variable_qtgui_chooser
  parameters:
    label: Waveform
    label0: '''Square'''
    label1: '''Triangular'''
    label2: '''Sawtooth'''
    num_opts: '3'
    option0: '''Square'''
    option1: '''Triangular'''
    option2: '''Sawtooth'''
    type: string
    value: '''Square'''
    widget: radio_buttons
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: (1 if waveform == 'Square' else (1 if waveform == 'Triangular' else -1)) * h1
    freq: 1*F0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: ((1/3) if waveform == 'Square' else (-1/9 if waveform == 'Triangular' else (-1/3))) * h3
    freq: 3*F0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: ((1/5) if waveform == 'Square' else (1/25 if waveform == 'Triangular' else (-1/5))) * h5
    freq: 5*F0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: ((1/7) if waveform == 'Square' else (-1/49 if waveform == 'Triangular' else (-1/7))) * h7
    freq: 7*F0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: (-1/8 if waveform == 'Sawtooth' else 0 )* h8
    freq: 8*F0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_1
  id: analog_sig_source_x
  parameters:
    amp: (-1/6 if waveform == 'Sawtooth' else 0 )* h6
    freq: 6*F0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0_1
  id: analog_sig_source_x
  parameters:
    amp: (-1/4 if waveform == 'Sawtooth' else 0 )* h4
    freq: 4*F0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: (-1/2 if waveform == 'Sawtooth' else 0 )* h1
    freq: 2*F0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '8'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0
  id: note
  parameters:
    note: Please use 8 harmonics for Sawtooth
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 3,0,1,4
    legend: 'False'
    name: Spectrum
    norm_window: 'True'
    showports: 'True'
    type: float
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 2,0,1,4
    label1: ''
    legend: 'False'
    name: Waveform
    size: '200'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_add_xx_0, '2']
- [analog_sig_source_x_0_0_0_0, '0', blocks_add_xx_0, '3']
- [analog_sig_source_x_0_0_0_0_0, '0', blocks_add_xx_0, '7']
- [analog_sig_source_x_0_0_0_1, '0', blocks_add_xx_0, '6']
- [analog_sig_source_x_0_0_1, '0', blocks_add_xx_0, '5']
- [analog_sig_source_x_0_1, '0', blocks_add_xx_0, '4']
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
