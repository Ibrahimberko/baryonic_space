options:
  parameters:
    generate_options: qt_gui
    id: projetransmit2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amplitude
  id: variable
  parameters:
    value: (b1+b2+b3+ba+b4+b5+b6+bb+b7+b8+b9+bc+b10+b0+b12+bd)*0.5
  states: {}
- name: b0
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 4,2,1,1
    label: '0'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: b1
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 1,1,1,1
    label: '1'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: b10
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 4,1,1,1
    label: '*'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: b12
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 4,3,1,1
    label: '#'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: b2
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 1,2,1,1
    label: '2'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: b3
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 1,3,1,1
    label: '3'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: b4
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 2,1,1,1
    label: '4'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: b5
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 2,2,1,1
    label: '5'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: b6
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 2,3,1,1
    label: '6'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: b7
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 3,1,1,1
    label: '7'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: b8
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 3,2,1,1
    label: '8'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: b9
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 3,3,1,1
    label: '9'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: ba
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 1,4,1,1
    label: A
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: bb
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 2,4,1,1
    label: B
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: bc
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 3,4,1,1
    label: C
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: bd
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 4,4,1,1
    label: D
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: freq1
  id: variable
  parameters:
    value: (b1+b2+b3+ba)*697+(b4+b5+b6+bb)*770+(b7+b8+b9+bc)*852+(bd+b10+b0+b12)*941
  states: {}
- name: freq2
  id: variable
  parameters:
    value: (b1+b4+b7+b10)*1209+(b2+b5+b8+b0)*1336+(b3+b6+b9+b12)*1477+(ba+bb+bc+bd)*1633
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    freq: freq1
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    freq: freq2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', audio_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
