options:
  parameters:
    author: ibrbe
    generate_options: qt_gui
    id: proje_receiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: debounce_interval
  id: variable_qtgui_range
  parameters:
    start: '0.1'
    step: '0.1'
    stop: '1'
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    start: '1e-07'
    step: '5e-06'
    stop: '1e-04'
    value: '1e-05'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: Mik
    samp_rate: '44100'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '707'
    low_cutoff_freq: '687'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '20'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '951'
    low_cutoff_freq: '931'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '20'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '1487'
    low_cutoff_freq: '1467'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '20'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_1_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '1346'
    low_cutoff_freq: '1326'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '20'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_1_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '862'
    low_cutoff_freq: '842'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '20'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_1_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '780'
    low_cutoff_freq: '760'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '20'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_1_0_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '1219'
    low_cutoff_freq: '1199'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '20'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_1_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '1643'
    low_cutoff_freq: '1623'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '20'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0_0_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import time
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          def __init__(self, threshold=0.00001, debounce_interval=0.2):
              super().__init__(
                  name='DTMF Decoder',
                  in_sig=[np.float32]*8,
                  out_sig=None
              )

              self.dtmf_map = [
                  ['1', '2', '3', 'A'],
                  ['4', '5', '6', 'B'],
                  ['7', '8', '9', 'C'],
                  ['*', '0', '#', 'D']
              ]

              self.threshold = threshold
              self.debounce_interval = debounce_interval
              self.history = ""
              self.current_digit = None
              self.ready = True
              self.last_time = 0

              self.message_port_register_out(pmt.intern("label_out"))

          def work(self, input_items, output_items):
              energies = [np.mean(items) for items in input_items]
              low_energies = energies[:4]
              high_energies = energies[4:]

              low_active = [i for i, val in enumerate(low_energies) if val > self.threshold]
              high_active = [i for i, val in enumerate(high_energies) if val > self.threshold]

              current_time = time.time()

              if len(low_active) == 1 and len(high_active) == 1:
                  digit = self.dtmf_map[low_active[0]][high_active[0]]

                  if self.ready and digit != self.current_digit and (current_time - self.last_time > self.debounce_interval):
                      self.history += digit
                      msg = pmt.cons(pmt.intern("text"), pmt.to_pmt(self.history))
                      self.message_port_pub(pmt.intern("label_out"), msg)

                      self.current_digit = digit
                      self.ready = False
                      self.last_time = current_time  # zaman güncelle
              else:
                  self.ready = True
                  self.current_digit = None

              return len(input_items[0])
    debounce_interval: debounce_interval
    threshold: threshold
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '20'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '20'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '20'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '20'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '20'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_2
  id: low_pass_filter
  parameters:
    cutoff_freq: '20'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_2_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '20'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_2_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '20'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    key: text
    label: DTFM Tuşu
    type: string
    value: '"Bekleniyor..."'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: '200000'
    fc: '0'
    fftsize: '1024'
    norm_window: 'True'
    type: float
    wintype: window.WIN_HAMMING
    ymin: '-70'
  states: {}

connections:
- [audio_source_0, '0', band_pass_filter_0, '0']
- [audio_source_0, '0', band_pass_filter_0_0, '0']
- [audio_source_0, '0', band_pass_filter_0_1, '0']
- [audio_source_0, '0', band_pass_filter_0_1_0, '0']
- [audio_source_0, '0', band_pass_filter_0_1_0_0, '0']
- [audio_source_0, '0', band_pass_filter_0_1_0_0_0, '0']
- [audio_source_0, '0', band_pass_filter_0_1_0_1, '0']
- [audio_source_0, '0', band_pass_filter_0_1_1, '0']
- [audio_source_0, '0', qtgui_freq_sink_x_1, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0_0, '0', blocks_multiply_xx_0_0_0_0, '0']
- [band_pass_filter_0_0, '0', blocks_multiply_xx_0_0_0_0, '1']
- [band_pass_filter_0_1, '0', blocks_multiply_xx_0_0_0_0_0_0_0, '0']
- [band_pass_filter_0_1, '0', blocks_multiply_xx_0_0_0_0_0_0_0, '1']
- [band_pass_filter_0_1_0, '0', blocks_multiply_xx_0_0_0_0_0_0, '0']
- [band_pass_filter_0_1_0, '0', blocks_multiply_xx_0_0_0_0_0_0, '1']
- [band_pass_filter_0_1_0_0, '0', blocks_multiply_xx_0_0_0, '0']
- [band_pass_filter_0_1_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [band_pass_filter_0_1_0_0_0, '0', blocks_multiply_xx_0_0, '0']
- [band_pass_filter_0_1_0_0_0, '0', blocks_multiply_xx_0_0, '1']
- [band_pass_filter_0_1_0_1, '0', blocks_multiply_xx_0_0_0_0_0, '0']
- [band_pass_filter_0_1_0_1, '0', blocks_multiply_xx_0_0_0_0_0, '1']
- [band_pass_filter_0_1_1, '0', blocks_multiply_xx_0_0_0_0_0_0_0_0, '0']
- [band_pass_filter_0_1_1, '0', blocks_multiply_xx_0_0_0_0_0_0_0_0, '1']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_0_0_0, '0', low_pass_filter_0_0_0, '0']
- [blocks_multiply_xx_0_0_0_0, '0', low_pass_filter_0_0_0_0, '0']
- [blocks_multiply_xx_0_0_0_0_0, '0', low_pass_filter_0_0_0_1, '0']
- [blocks_multiply_xx_0_0_0_0_0_0, '0', low_pass_filter_0_0_0_2, '0']
- [blocks_multiply_xx_0_0_0_0_0_0_0, '0', low_pass_filter_0_0_0_2_0, '0']
- [blocks_multiply_xx_0_0_0_0_0_0_0_0, '0', low_pass_filter_0_0_0_2_1, '0']
- [epy_block_0, label_out, qtgui_edit_box_msg_0, val]
- [low_pass_filter_0, '0', epy_block_0, '0']
- [low_pass_filter_0_0, '0', epy_block_0, '1']
- [low_pass_filter_0_0_0, '0', epy_block_0, '2']
- [low_pass_filter_0_0_0_0, '0', epy_block_0, '3']
- [low_pass_filter_0_0_0_1, '0', epy_block_0, '4']
- [low_pass_filter_0_0_0_2, '0', epy_block_0, '5']
- [low_pass_filter_0_0_0_2_0, '0', epy_block_0, '6']
- [low_pass_filter_0_0_0_2_1, '0', epy_block_0, '7']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
