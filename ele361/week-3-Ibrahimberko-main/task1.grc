options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Q1
  states: {}

blocks:
- name: high_freq
  id: variable_qtgui_range
  parameters:
    start: '4000'
    step: '1'
    stop: '6000'
    value: '6000'
    widget: eng
  states: {}
- name: low_freq
  id: variable_qtgui_range
  parameters:
    start: '4000'
    step: '1'
    stop: '6000'
    value: '4000'
    widget: eng
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: high_freq
    interp: '1'
    low_cutoff_freq: low_freq
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [analog_noise_source_x_0, '0', band_pass_filter_0, '0']
- [band_pass_filter_0, '0', audio_sink_0, '0']
- [band_pass_filter_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
